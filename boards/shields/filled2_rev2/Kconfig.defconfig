## boards/shields/filled2_rev2/Kconfig.defconfig
```kconfig
if SHIELD_FILLED2_REV2

config ZMK_KEYBOARD_NAME
    default "filled2_rev2"

endif
```
